# Keil uVision project Example_MassStorageDevice.uvproj, settings and files
target LPC17xx (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MassStorageDevice
  c flags: Optim=1
  c define: __LPC17XX__ USB_DEVICE_ONLY
  c misc: --gnu
  c include: ..\..\..\..\CDL\CMSISv2p00_LPC17xx\inc;..\..\..\..\CDL\LPC17xxLib\inc;..\..\..\..\BSP;..\..\..\..\nxpUSBlib\Drivers\USB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./: Descriptors.c MassStorage.c
    ./Lib/: DataRam.c SCSI.c
  group lib
    ../../../../nxpUSBLib/: nxpUSBlib.lib
    ../../../../BSP/: BSP.lib
    ../../../../CDL/: CDL.lib
