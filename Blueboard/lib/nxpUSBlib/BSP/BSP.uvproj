# Keil uVision project BSP.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: BSP (library)
  AfterMake: cmd /c copy /y "$L@L.lib" .\
  c flags: Optim=1
  c define: __LPC17XX__ BOARD=BOARD_MCB1700
  c include: ..\CDL\CMSISv2p00_LPC17xx\inc;..\CDL\LPC17xxLib\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./: bsp.c
    ./MCB1700/: bsp_MCB1700.c
