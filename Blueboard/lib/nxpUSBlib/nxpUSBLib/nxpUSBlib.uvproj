# Keil uVision project nxpUSBlib.uvproj, settings and files
target LPC17xx_Device (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: nxpUSBlib (library)
  AfterMake: cmd /c copy /y "$L@L.lib" .\
  c flags: Optim=1
  c define: __LPC17XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99
  c include: ..\CDL\CMSISv2p00_LPC17xx\inc;..\CDL\LPC17xxLib\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Class
    ./Drivers/USB/Class/Device/: Audio.c CDC.c HID.c MassStorage.c MIDI.c RNDIS.c
  group Core
    ./Drivers/USB/Core/: ConfigDescriptor.c DeviceStandardReq.c Events.c HostStandardReq.c USBTask.c
  group LPC
    ./Drivers/USB/Core/LPC/: Device_LPC.c Endpoint_LPC.c EndpointStream_LPC.c Host_LPC.c Pipe_LPC.c PipeStream_LPC.c USBController_LPC.c
  group HAL
    ./Drivers/USB/Core/LPC/HAL/: HAL_LPC.c
    ./Drivers/USB/Core/LPC/HAL/LPC18XX/: HAL_LPC18xx.c
    ./Drivers/USB/Core/LPC/HAL/LPC17XX/: HAL_LPC17xx.c
    ./Drivers/USB/Core/LPC/HAL/LPC11UXX/: HAL_LPC11Uxx.c
  group DCD
    ./Drivers/USB/Core/LPC/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
    ./Drivers/USB/Core/LPC/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ./Drivers/USB/Core/LPC/DCD/LPC18XX/: Endpoint_LPC18xx.c
  group HCD
    ./Drivers/USB/Core/LPC/HCD/: HCD.c
    ./Drivers/USB/Core/LPC/HCD/OHCI/: OHCI.c
    ./Drivers/USB/Core/LPC/HCD/EHCI/: EHCI.c
